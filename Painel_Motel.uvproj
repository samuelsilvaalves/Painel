# Keil uVision project Painel_Motel.uvproj, settings and files
target Painel_Motel (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Painel_Motel +hex
  c flags: wLevel=2
  c define: LPC1700 FLASH_512
  c include: .\inc;.\inc\file_system;.\inc\IR;C:\Keil\ARM\RL\TCPnet\Drivers;.\inc\tcpip
  asm include: .\asm
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup
    ./asm/: startup_LPC17xx.s
    ./src/: system_LPC17xx.c
  group src
    ./src/: main.c uart.c timer.c extint.c
  group file
    ./src/file_system/: File_Config.c SPI_LPC17xx.c MSD_SD_File.c
  group retarget
    ./src/: Retarget.c
  group lib
    ./lib/: FS_CM3.lib TCP_CM3.lib
  group doc
    ./other/: leia-me.txt
  group IR
    ./src/IR/: control_ir.c ir.c pwm_ir.c cmds_ir.c
  group Touch
    ./src/: touch.c
  group Register
    ./src/: register.c
  group tcpip
    ./src/tcpip/: EMAC_LPC17xx.c FTP_uif.c Net_Config.c tcpip.c
